# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: xunji.c xunji.h main.c car.c car.h motor.c motor.h
    ../../../程序源码/KeilProject/11-1 蜂鸣器播放提示音/: Buzzer.c Buzzer.h
